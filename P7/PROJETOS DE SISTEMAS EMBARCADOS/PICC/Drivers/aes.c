///////////////////////////////////////////////////////////////////////////////
////                                 aes.c                                 ////
////                                                                       ////
////  Driver for encrypting/decrypting AES-128 ECB or CBC data.            ////
////                                                                       ////
///////////////////////////////////////////////////////////////////////////////
////                                                                       ////
////  Preprocessors:                                                       ////
////                                                                       ////
////     AES_BLOCK_TYPE - sets the AES-128 encryption/decryption type, can ////
////        be either AES_TYPE_ECB or AES_TYPE_CBC.  ECB encrypts/decrypts ////
////        each 128 bit block, 16 bytes, separately.  CBC each 128 bit    ////
////        block depends on the block before it, the first block being    ////
////        encrypted/decrypted uses an initial value.  Default is         ////
////        AES_TYPE_EBC if not defined before this driver is included.    ////
////                                                                       ////
////     AES_USE_GF28MULTIPLY_TABLES - sets whether to use lookup tables   ////
////        to perform GF (2^8) multiplication or a function.  TRUE uses   ////
////        lookup tables or FALSE uses function, uses less program memory ////
////        but takes ~3.1 times longer to encrypt data and ~4.1 times     ////
////        longer to decrypt data.  Additional encrypt/decrypt times      ////
////        determined by encrypting and decrypting 16 bytes of data using ////
////        a dsPIC33EP512GM710 running 100MHz.  Default is TRUE if not    ////
////        defined before driver is included.                             ////
////                                                                       ////
////  API:                                                                 ////
////                                                                       ////
////     init_aes_key() - used to initialize the encryption/decryption     ////
////        key, must be called before any other functions are called or   ////
////        any time the encryption/decryption key is changed.             ////
////                                                                       ////
////     encrypt_aes() - used to encrypt the data.                         ////
////                                                                       ////
////     decrypt_aes() = used to decrypt the data.                         ////
////                                                                       ////
///////////////////////////////////////////////////////////////////////////////
////           (C) Copyright 1996,2019 Custom Computer Services            ////
////  This source code may only be used by licensed users of the CCS C     ////
////  compiler.  This source code may only be distributed to other         ////
////  licensed users of the CCS C compiler.  No other use, reproduction or ////
////  distribution is permitted without written permission.  Derivative    ////
////  programs created using this software in object code form are not     ////
////  restricted in any way.                                               ////
////                        http://www.ccsinfo.com                         ////
///////////////////////////////////////////////////////////////////////////////

#ifndef __AES_C__
#define __AES_C__

#include <stdint.h>

typedef enum
{
   AES_TYPE_ECB,
   AES_TYPE_CBC
} AES_TYPE;

#ifndef AES_BLOCK_TYPE
 #define AES_BLOCK_TYPE    AES_TYPE_ECB
#endif

#ifndef AES_USE_GF28MULTIPLY_TABLES
 #define AES_USE_GF28MULTIPLY_TABLES   TRUE
#endif

const uint8_t SBox[256] = {0x63,0x7C,0x77,0x7B,0xF2,0x6B,0x6F,0xC5,0x30,0x01,0x67,0x2B,0xFE,0xD7,0xAB,0x76,
                           0xCA,0x82,0xC9,0x7D,0xFA,0x59,0x47,0xF0,0xAD,0xD4,0xA2,0xAF,0x9C,0xA4,0x72,0xC0,
                           0xB7,0xFD,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
                           0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
                           0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
                           0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
                           0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
                           0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
                           0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
                           0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
                           0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
                           0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
                           0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
                           0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
                           0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
                           0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16};

const uint8_t InverseSBox[256] = {0x52,0x09,0x6a,0xd5,0x30,0x36,0xa5,0x38,0xbf,0x40,0xa3,0x9e,0x81,0xf3,0xd7,0xfb,
                                  0x7c,0xe3,0x39,0x82,0x9b,0x2f,0xff,0x87,0x34,0x8e,0x43,0x44,0xc4,0xde,0xe9,0xcb,
                                  0x54,0x7b,0x94,0x32,0xa6,0xc2,0x23,0x3d,0xee,0x4c,0x95,0x0b,0x42,0xfa,0xc3,0x4e,
                                  0x08,0x2e,0xa1,0x66,0x28,0xd9,0x24,0xb2,0x76,0x5b,0xa2,0x49,0x6d,0x8b,0xd1,0x25,
                                  0x72,0xf8,0xf6,0x64,0x86,0x68,0x98,0x16,0xd4,0xa4,0x5c,0xcc,0x5d,0x65,0xb6,0x92,
                                  0x6c,0x70,0x48,0x50,0xfd,0xed,0xb9,0xda,0x5e,0x15,0x46,0x57,0xa7,0x8d,0x9d,0x84,
                                  0x90,0xd8,0xab,0x00,0x8c,0xbc,0xd3,0x0a,0xf7,0xe4,0x58,0x05,0xb8,0xb3,0x45,0x06,
                                  0xd0,0x2c,0x1e,0x8f,0xca,0x3f,0x0f,0x02,0xc1,0xaf,0xbd,0x03,0x01,0x13,0x8a,0x6b,
                                  0x3a,0x91,0x11,0x41,0x4f,0x67,0xdc,0xea,0x97,0xf2,0xcf,0xce,0xf0,0xb4,0xe6,0x73,
                                  0x96,0xac,0x74,0x22,0xe7,0xad,0x35,0x85,0xe2,0xf9,0x37,0xe8,0x1c,0x75,0xdf,0x6e,
                                  0x47,0xf1,0x1a,0x71,0x1d,0x29,0xc5,0x89,0x6f,0xb7,0x62,0x0e,0xaa,0x18,0xbe,0x1b,
                                  0xfc,0x56,0x3e,0x4b,0xc6,0xd2,0x79,0x20,0x9a,0xdb,0xc0,0xfe,0x78,0xcd,0x5a,0xf4,
                                  0x1f,0xdd,0xa8,0x33,0x88,0x07,0xc7,0x31,0xb1,0x12,0x10,0x59,0x27,0x80,0xec,0x5f,
                                  0x60,0x51,0x7f,0xa9,0x19,0xb5,0x4a,0x0d,0x2d,0xe5,0x7a,0x9f,0x93,0xc9,0x9c,0xef,
                                  0xa0,0xe0,0x3b,0x4d,0xae,0x2a,0xf5,0xb0,0xc8,0xeb,0xbb,0x3c,0x83,0x53,0x99,0x61,
                                  0x17,0x2b,0x04,0x7e,0xba,0x77,0xd6,0x26,0xe1,0x69,0x14,0x63,0x55,0x21,0x0c,0x7d};

#if AES_USE_GF28MULTIPLY_TABLES == TRUE
const uint8_t GF28Multiply2[256] = {0x00,0x02,0x04,0x06,0x08,0x0A,0x0C,0x0E,0x10,0x12,0x14,0x16,0x18,0x1A,0x1C,0x1E,
                                    0x20,0x22,0x24,0x26,0x28,0x2A,0x2C,0x2E,0x30,0x32,0x34,0x36,0x38,0x3A,0x3C,0x3E,
                                    0x40,0x42,0x44,0x46,0x48,0x4A,0x4C,0x4E,0x50,0x52,0x54,0x56,0x58,0x5A,0x5C,0x5E,
                                    0x60,0x62,0x64,0x66,0x68,0x6A,0x6C,0x6E,0x70,0x72,0x74,0x76,0x78,0x7A,0x7C,0x7E,
                                    0x80,0x82,0x84,0x86,0x88,0x8A,0x8C,0x8E,0x90,0x92,0x94,0x96,0x98,0x9A,0x9C,0x9E,
                                    0xA0,0xA2,0xA4,0xA6,0xA8,0xAA,0xAC,0xAE,0xB0,0xB2,0xB4,0xB6,0xB8,0xBA,0xBC,0xBE,
                                    0xC0,0xC2,0xC4,0xC6,0xC8,0xCA,0xCC,0xCE,0xD0,0xD2,0xD4,0xD6,0xD8,0xDA,0xDC,0xDE,
                                    0xE0,0xE2,0xE4,0xE6,0xE8,0xEA,0xEC,0xEE,0xF0,0xF2,0xF4,0xF6,0xF8,0xFA,0xFC,0xFE,
                                    0x1B,0x19,0x1F,0x1D,0x13,0x11,0x17,0x15,0x0B,0x09,0x0F,0x0D,0x03,0x01,0x07,0x05,
                                    0x3B,0x39,0x3F,0x3D,0x33,0x31,0x37,0x35,0x2B,0x29,0x2F,0x2D,0x23,0x21,0x27,0x25,
                                    0x5B,0x59,0x5F,0x5D,0x53,0x51,0x57,0x55,0x4B,0x49,0x4F,0x4D,0x43,0x41,0x47,0x45,
                                    0x7B,0x79,0x7F,0x7D,0x73,0x71,0x77,0x75,0x6B,0x69,0x6F,0x6D,0x63,0x61,0x67,0x65,
                                    0x9B,0x99,0x9F,0x9D,0x93,0x91,0x97,0x95,0x8B,0x89,0x8F,0x8D,0x83,0x81,0x87,0x85,
                                    0xBB,0xB9,0xBF,0xBD,0xB3,0xB1,0xB7,0xB5,0xAB,0xA9,0xAF,0xAD,0xA3,0xA1,0xA7,0xA5,
                                    0xDB,0xD9,0xDF,0xDD,0xD3,0xD1,0xD7,0xD5,0xCB,0xC9,0xCF,0xCD,0xC3,0xC1,0xC7,0xC5,
                                    0xFB,0xF9,0xFF,0xFD,0xF3,0xF1,0xF7,0xF5,0xEB,0xE9,0xEF,0xED,0xE3,0xE1,0xE7,0xE5};

const uint8_t GF28Multiply3[256] = {0x00,0x03,0x06,0x05,0x0C,0x0F,0x0A,0x09,0x18,0x1B,0x1E,0x1D,0x14,0x17,0x12,0x11,
                                    0x30,0x33,0x36,0x35,0x3C,0x3F,0x3A,0x39,0x28,0x2B,0x2E,0x2D,0x24,0x27,0x22,0x21,
                                    0x60,0x63,0x66,0x65,0x6C,0x6F,0x6A,0x69,0x78,0x7B,0x7E,0x7D,0x74,0x77,0x72,0x71,
                                    0x50,0x53,0x56,0x55,0x5C,0x5F,0x5A,0x59,0x48,0x4B,0x4E,0x4D,0x44,0x47,0x42,0x41,
                                    0xC0,0xC3,0xC6,0xC5,0xCC,0xCF,0xCA,0xC9,0xD8,0xDB,0xDE,0xDD,0xD4,0xD7,0xD2,0xD1,
                                    0xF0,0xF3,0xF6,0xF5,0xFC,0xFF,0xFA,0xF9,0xE8,0xEB,0xEE,0xED,0xE4,0xE7,0xE2,0xE1,
                                    0xA0,0xA3,0xA6,0xA5,0xAC,0xAF,0xAA,0xA9,0xB8,0xBB,0xBE,0xBD,0xB4,0xB7,0xB2,0xB1,
                                    0x90,0x93,0x96,0x95,0x9C,0x9F,0x9A,0x99,0x88,0x8B,0x8E,0x8D,0x84,0x87,0x82,0x81,
                                    0x9B,0x98,0x9D,0x9E,0x97,0x94,0x91,0x92,0x83,0x80,0x85,0x86,0x8F,0x8C,0x89,0x8A,
                                    0xAB,0xA8,0xAD,0xAE,0xA7,0xA4,0xA1,0xA2,0xB3,0xB0,0xB5,0xB6,0xBF,0xBC,0xB9,0xBA,
                                    0xFB,0xF8,0xFD,0xFE,0xF7,0xF4,0xF1,0xF2,0xE3,0xE0,0xE5,0xE6,0xEF,0xEC,0xE9,0xEA,
                                    0xCB,0xC8,0xCD,0xCE,0xC7,0xC4,0xC1,0xC2,0xD3,0xD0,0xD5,0xD6,0xDF,0xDC,0xD9,0xDA,
                                    0x5B,0x58,0x5D,0x5E,0x57,0x54,0x51,0x52,0x43,0x40,0x45,0x46,0x4F,0x4C,0x49,0x4A,
                                    0x6B,0x68,0x6D,0x6E,0x67,0x64,0x61,0x62,0x73,0x70,0x75,0x76,0x7F,0x7C,0x79,0x7A,
                                    0x3B,0x38,0x3D,0x3E,0x37,0x34,0x31,0x32,0x23,0x20,0x25,0x26,0x2F,0x2C,0x29,0x2A,
                                    0x0B,0x08,0x0D,0x0E,0x07,0x04,0x01,0x02,0x13,0x10,0x15,0x16,0x1F,0x1C,0x19,0x1A};

const uint8_t GF28Multiply9[256] = {0x00,0x09,0x12,0x1B,0x24,0x2D,0x36,0x3F,0x48,0x41,0x5A,0x53,0x6C,0x65,0x7E,0x77,
                                    0x90,0x99,0x82,0x8B,0xB4,0xBD,0xA6,0xAF,0xD8,0xD1,0xCA,0xC3,0xFC,0xF5,0xEE,0xE7,
                                    0x3B,0x32,0x29,0x20,0x1F,0x16,0x0D,0x04,0x73,0x7A,0x61,0x68,0x57,0x5E,0x45,0x4C,
                                    0xAB,0xA2,0xB9,0xB0,0x8F,0x86,0x9D,0x94,0xE3,0xEA,0xF1,0xF8,0xC7,0xCE,0xD5,0xDC,
                                    0x76,0x7F,0x64,0x6D,0x52,0x5B,0x40,0x49,0x3E,0x37,0x2C,0x25,0x1A,0x13,0x08,0x01,
                                    0xE6,0xEF,0xF4,0xFD,0xC2,0xCB,0xD0,0xD9,0xAE,0xA7,0xBC,0xB5,0x8A,0x83,0x98,0x91,
                                    0x4D,0x44,0x5F,0x56,0x69,0x60,0x7B,0x72,0x05,0x0C,0x17,0x1E,0x21,0x28,0x33,0x3A,
                                    0xDD,0xD4,0xCF,0xC6,0xF9,0xF0,0xEB,0xE2,0x95,0x9C,0x87,0x8E,0xB1,0xB8,0xA3,0xAA,
                                    0xEC,0xE5,0xFE,0xF7,0xC8,0xC1,0xDA,0xD3,0xA4,0xAD,0xB6,0xBF,0x80,0x89,0x92,0x9B,
                                    0x7C,0x75,0x6E,0x67,0x58,0x51,0x4A,0x43,0x34,0x3D,0x26,0x2F,0x10,0x19,0x02,0x0B,
                                    0xD7,0xDE,0xC5,0xCC,0xF3,0xFA,0xE1,0xE8,0x9F,0x96,0x8D,0x84,0xBB,0xB2,0xA9,0xA0,
                                    0x47,0x4E,0x55,0x5C,0x63,0x6A,0x71,0x78,0x0F,0x06,0x1D,0x14,0x2B,0x22,0x39,0x30,
                                    0x9A,0x93,0x88,0x81,0xBE,0xB7,0xAC,0xA5,0xD2,0xDB,0xC0,0xC9,0xF6,0xFF,0xE4,0xED,
                                    0x0A,0x03,0x18,0x11,0x2E,0x27,0x3C,0x35,0x42,0x4B,0x50,0x59,0x66,0x6F,0x74,0x7D,
                                    0xA1,0xA8,0xB3,0xBA,0x85,0x8C,0x97,0x9E,0xE9,0xE0,0xFB,0xF2,0xCD,0xC4,0xDF,0xD6,
                                    0x31,0x38,0x23,0x2A,0x15,0x1C,0x07,0x0E,0x79,0x70,0x6B,0x62,0x5D,0x54,0x4F,0x46};

const uint8_t GF28Multiply11[256] = {0x00,0x0B,0x16,0x1D,0x2C,0x27,0x3A,0x31,0x58,0x53,0x4E,0x45,0x74,0x7F,0x62,0x69,
                                     0xB0,0xBB,0xA6,0xAD,0x9C,0x97,0x8A,0x81,0xE8,0xE3,0xFE,0xF5,0xC4,0xCF,0xD2,0xD9,
                                     0x7B,0x70,0x6D,0x66,0x57,0x5C,0x41,0x4A,0x23,0x28,0x35,0x3E,0x0F,0x04,0x19,0x12,
                                     0xCB,0xC0,0xDD,0xD6,0xE7,0xEC,0xF1,0xFA,0x93,0x98,0x85,0x8E,0xBF,0xB4,0xA9,0xA2,
                                     0xF6,0xFD,0xE0,0xEB,0xDA,0xD1,0xCC,0xC7,0xAE,0xA5,0xB8,0xB3,0x82,0x89,0x94,0x9F,
                                     0x46,0x4D,0x50,0x5B,0x6A,0x61,0x7C,0x77,0x1E,0x15,0x08,0x03,0x32,0x39,0x24,0x2F,
                                     0x8D,0x86,0x9B,0x90,0xA1,0xAA,0xB7,0xBC,0xD5,0xDE,0xC3,0xC8,0xF9,0xF2,0xEF,0xE4,
                                     0x3D,0x36,0x2B,0x20,0x11,0x1A,0x07,0x0C,0x65,0x6E,0x73,0x78,0x49,0x42,0x5F,0x54,
                                     0xF7,0xFC,0xE1,0xEA,0xDB,0xD0,0xCD,0xC6,0xAF,0xA4,0xB9,0xB2,0x83,0x88,0x95,0x9E,
                                     0x47,0x4C,0x51,0x5A,0x6B,0x60,0x7D,0x76,0x1F,0x14,0x09,0x02,0x33,0x38,0x25,0x2E,
                                     0x8C,0x87,0x9A,0x91,0xA0,0xAB,0xB6,0xBD,0xD4,0xDF,0xC2,0xC9,0xF8,0xF3,0xEE,0xE5,
                                     0x3C,0x37,0x2A,0x21,0x10,0x1B,0x06,0x0D,0x64,0x6F,0x72,0x79,0x48,0x43,0x5E,0x55,
                                     0x01,0x0A,0x17,0x1C,0x2D,0x26,0x3B,0x30,0x59,0x52,0x4F,0x44,0x75,0x7E,0x63,0x68,
                                     0xB1,0xBA,0xA7,0xAC,0x9D,0x96,0x8B,0x80,0xE9,0xE2,0xFF,0xF4,0xC5,0xCE,0xD3,0xD8,
                                     0x7A,0x71,0x6C,0x67,0x56,0x5D,0x40,0x4B,0x22,0x29,0x34,0x3F,0x0E,0x05,0x18,0x13,
                                     0xCA,0xC1,0xDC,0xD7,0xE6,0xED,0xF0,0xFB,0x92,0x99,0x84,0x8F,0xBE,0xB5,0xA8,0xA3};

const uint8_t GF28Multiply13[256] = {0x00,0x0D,0x1A,0x17,0x34,0x39,0x2E,0x23,0x68,0x65,0x72,0x7F,0x5C,0x51,0x46,0x4B,
                                     0xD0,0xDD,0xCA,0xC7,0xE4,0xE9,0xFE,0xF3,0xB8,0xB5,0xA2,0xAF,0x8C,0x81,0x96,0x9B,
                                     0xBB,0xB6,0xA1,0xAC,0x8F,0x82,0x95,0x98,0xD3,0xDE,0xC9,0xC4,0xE7,0xEA,0xFD,0xF0,
                                     0x6B,0x66,0x71,0x7C,0x5F,0x52,0x45,0x48,0x03,0x0E,0x19,0x14,0x37,0x3A,0x2D,0x20,
                                     0x6D,0x60,0x77,0x7A,0x59,0x54,0x43,0x4E,0x05,0x08,0x1F,0x12,0x31,0x3C,0x2B,0x26,
                                     0xBD,0xB0,0xA7,0xAA,0x89,0x84,0x93,0x9E,0xD5,0xD8,0xCF,0xC2,0xE1,0xEC,0xFB,0xF6,
                                     0xD6,0xDB,0xCC,0xC1,0xE2,0xEF,0xF8,0xF5,0xBE,0xB3,0xA4,0xA9,0x8A,0x87,0x90,0x9D,
                                     0x06,0x0B,0x1C,0x11,0x32,0x3F,0x28,0x25,0x6E,0x63,0x74,0x79,0x5A,0x57,0x40,0x4D,
                                     0xDA,0xD7,0xC0,0xCD,0xEE,0xE3,0xF4,0xF9,0xB2,0xBF,0xA8,0xA5,0x86,0x8B,0x9C,0x91,
                                     0x0A,0x07,0x10,0x1D,0x3E,0x33,0x24,0x29,0x62,0x6F,0x78,0x75,0x56,0x5B,0x4C,0x41,
                                     0x61,0x6C,0x7B,0x76,0x55,0x58,0x4F,0x42,0x09,0x04,0x13,0x1E,0x3D,0x30,0x27,0x2A,
                                     0xB1,0xBC,0xAB,0xA6,0x85,0x88,0x9F,0x92,0xD9,0xD4,0xC3,0xCE,0xED,0xE0,0xF7,0xFA,
                                     0xB7,0xBA,0xAD,0xA0,0x83,0x8E,0x99,0x94,0xDF,0xD2,0xC5,0xC8,0xEB,0xE6,0xF1,0xFC,
                                     0x67,0x6A,0x7D,0x70,0x53,0x5E,0x49,0x44,0x0F,0x02,0x15,0x18,0x3B,0x36,0x21,0x2C,
                                     0x0C,0x01,0x16,0x1B,0x38,0x35,0x22,0x2F,0x64,0x69,0x7E,0x73,0x50,0x5D,0x4A,0x47,
                                     0xDC,0xD1,0xC6,0xCB,0xE8,0xE5,0xF2,0xFF,0xB4,0xB9,0xAE,0xA3,0x80,0x8D,0x9A,0x97};

const uint8_t GF28Multiply14[256] = {0x00,0x0E,0x1C,0x12,0x38,0x36,0x24,0x2A,0x70,0x7E,0x6C,0x62,0x48,0x46,0x54,0x5A,
                                     0xE0,0xEE,0xFC,0xF2,0xD8,0xD6,0xC4,0xCA,0x90,0x9E,0x8C,0x82,0xA8,0xA6,0xB4,0xBA,
                                     0xDB,0xD5,0xC7,0xC9,0xE3,0xED,0xFF,0xF1,0xAB,0xA5,0xB7,0xB9,0x93,0x9D,0x8F,0x81,
                                     0x3B,0x35,0x27,0x29,0x03,0x0D,0x1F,0x11,0x4B,0x45,0x57,0x59,0x73,0x7D,0x6F,0x61,
                                     0xAD,0xA3,0xB1,0xBF,0x95,0x9B,0x89,0x87,0xDD,0xD3,0xC1,0xCF,0xE5,0xEB,0xF9,0xF7,
                                     0x4D,0x43,0x51,0x5F,0x75,0x7B,0x69,0x67,0x3D,0x33,0x21,0x2F,0x05,0x0B,0x19,0x17,
                                     0x76,0x78,0x6A,0x64,0x4E,0x40,0x52,0x5C,0x06,0x08,0x1A,0x14,0x3E,0x30,0x22,0x2C,
                                     0x96,0x98,0x8A,0x84,0xAE,0xA0,0xB2,0xBC,0xE6,0xE8,0xFA,0xF4,0xDE,0xD0,0xC2,0xCC,
                                     0x41,0x4F,0x5D,0x53,0x79,0x77,0x65,0x6B,0x31,0x3F,0x2D,0x23,0x09,0x07,0x15,0x1B,
                                     0xA1,0xAF,0xBD,0xB3,0x99,0x97,0x85,0x8B,0xD1,0xDF,0xCD,0xC3,0xE9,0xE7,0xF5,0xFB,
                                     0x9A,0x94,0x86,0x88,0xA2,0xAC,0xBE,0xB0,0xEA,0xE4,0xF6,0xF8,0xD2,0xDC,0xCE,0xC0,
                                     0x7A,0x74,0x66,0x68,0x42,0x4C,0x5E,0x50,0x0A,0x04,0x16,0x18,0x32,0x3C,0x2E,0x20,
                                     0xEC,0xE2,0xF0,0xFE,0xD4,0xDA,0xC8,0xC6,0x9C,0x92,0x80,0x8E,0xA4,0xAA,0xB8,0xB6,
                                     0x0C,0x02,0x10,0x1E,0x34,0x3A,0x28,0x26,0x7C,0x72,0x60,0x6E,0x44,0x4A,0x58,0x56,
                                     0x37,0x39,0x2B,0x25,0x0F,0x01,0x13,0x1D,0x47,0x49,0x5B,0x55,0x7F,0x71,0x63,0x6D,
                                     0xD7,0xD9,0xCB,0xC5,0xEF,0xE1,0xF3,0xFD,0xA7,0xA9,0xBB,0xB5,0x9F,0x91,0x83,0x8D};
#endif

const uint8_t rCon[10] = {0x01,0x02,0x04,0x08,0x10,0x20,0x40,0x80,0x1B,0x36};

uint32_t RoundKey[11][4];

typedef union
{
   uint8_t b[4];
   uint32_t dw;
} uint32_union_t;

#if AES_USE_GF28MULTIPLY_TABLES == FALSE
uint8_t MultiplyGF28(uint8_t a, uint8_t b);
#endif
void ShiftRows(uint32_union_t *Data, uint8_t Row, uint8_t Bytes, int1 IsInverse=FALSE);
void InverseShiftRows(uint32_union_t *Data, uint8_t Row, uint8_t Bytes);
void MixColumns(uint32_union_t *Data, uint8_t Column);
void InverseMixColumns(uint32_union_t *Data, uint8_t Column);


///////////////////////////////////////////////////////////////////////////////
// init_aes_key()
//
// Initializes the encryption/decryption key, must be called before any other 
// functions or any time the encryption/decryption key is changed.
//
// Parameters:
//    Key - a pointer pointing to the array contain the AES key to encrypt and
//          decrypt the data with.
//
// Returns - Nothing.
///////////////////////////////////////////////////////////////////////////////
void init_aes_key(uint8_t *Key)
{
   uint8_t i, j, k;
   uint32_union_t rValue;
   uint32_union_t sValue;
   uint32_union_t xValue;
   
   RoundKey[0][0] = make32(Key[3], Key[2], Key[1], Key[0]);
   RoundKey[0][1] = make32(Key[7], Key[6], Key[5], Key[4]);
   RoundKey[0][2] = make32(Key[11], Key[10], Key[9], Key[8]);
   RoundKey[0][3] = make32(Key[15], Key[14], Key[13], Key[12]);
   
   for(i=1,j=0;i<11;i++,j++)
   {
      rValue.dw = RoundKey[i-1][3];
      for(k=0;k<8;k++)
         rotate_right(rValue.b, 4);
      
      for(k=0;k<4;k++)
         sValue.b[k] = SBox[rValue.b[k]];
      
      xValue.dw = sValue.dw;
      xValue.b[0] ^= rCon[j];
      
      RoundKey[i][0] = RoundKey[j][0] ^ xValue.dw;
      RoundKey[i][1] = RoundKey[i][0] ^ RoundKey[j][1];
      RoundKey[i][2] = RoundKey[i][1] ^ RoundKey[j][2];
      RoundKey[i][3] = RoundKey[i][2] ^ RoundKey[j][3];
   }
}

///////////////////////////////////////////////////////////////////////////////
// encrypt_aes()
//
// Used to encrypt the data being passed to it.  Data is encrypted in 128 bit
// blocks, 16 bytes.  If number of bytes passed to function is not a multiple
// of 16, 0x00 will be appended to data to make it a multiple of 16.
// 
// Parameters:
//    Data - array containing data to encrypt, the result is also returned 
//           to this array.  So the array must be big enough to receive the 
//           encrypted data, size must be a multiple of 16 bytes.
//
//    Count - the number of bytes to encrypt.
//
//    IV - only used for CBC type, it's an array containing the initial value
//         to xor the first block of data with.
//
// Returns - Nothing.
///////////////////////////////////////////////////////////////////////////////
void encrypt_aes(uint8_t *Data, uint16_t Count, uint8_t *IV = 0)
{
   union
   {
      uint8_t b[16];
      uint32_union_t u[4];
   } eData;
   uint8_t i,j,k;
   uint8_t Loops;
   uint16_t dCount = 0;
   uint16_t sCount = 0;
  #if AES_BLOCK_TYPE == AES_TYPE_CBC
   uint8_t cbcIndex = 0;
  #endif
   
   Loops = Count / 16;
   
   if((Count % 16) != 0)
      Loops++;
   
   for(i=0;i<Loops;i++)
   {
      for(j=0;j<4;j++)
      {
         for(k=0;k<4;k++,dCount++)
         {
            if(dCount >= Count)
               eData.u[j].b[k] = 0x00;
            else
               eData.u[j].b[k] = Data[dCount];
         }
      }
      
      eData.u[0].dw ^= RoundKey[0][0];
      eData.u[1].dw ^= RoundKey[0][1];
      eData.u[2].dw ^= RoundKey[0][2];
      eData.u[3].dw ^= RoundKey[0][3];
      
     #if AES_BLOCK_TYPE == AES_TYPE_CBC
      if(i == 0)
      {
         if(IV != 0)
         {
            for(j=0;j<4;j++)
            {
               for(k=0;k<4;k++)
                  eData.u[j].b[k] ^= IV[(j*4) + k];
            }
         }
      }
      else
      {
         for(j=0;j<4;j++)
         {
            for(k=0;k<4;k++,cbcIndex++)
               eData.u[j].b[k] ^= Data[cbcIndex];
         }
      }
     #endif
      
      for(j=1;j<11;j++)
      {
         //SubBytes
         for(k=0;k<16;k++)
            eData.b[k] = SBox[eData.b[k]];
         
         //ShiftRows
         ShiftRows((uint32_union_t *)&eData, 1, 1);
         ShiftRows((uint32_union_t *)&eData, 2, 2);
         ShiftRows((uint32_union_t *)&eData, 3, 3);
         
         if(j < 10)
         {
            //MixColumns
            for(k=0;k<4;k++)
               MixColumns((uint32_union_t *)&eData, k);
         }
         
         //RoundKey
         eData.u[0].dw ^= RoundKey[j][0];
         eData.u[1].dw ^= RoundKey[j][1];
         eData.u[2].dw ^= RoundKey[j][2];
         eData.u[3].dw ^= RoundKey[j][3];
      }
      
      for(j=0;j<16;j++,sCount++)
         Data[sCount] = eData.b[j];
   }
}

///////////////////////////////////////////////////////////////////////////////
// decrypt_aes()
//
// Used to decrypt the data being passed to it.  Data is decrypted in 128 bit
// blocks, 16 bytes.  If number of bytes to decrypt is not a multiple of 16 the
// data passed to it must be.
//
// Parameters:
//    Data - array containing the data to decrypt, the decrypted data is also 
//           returned to this array.  The array must be a multiple of 16 bytes
//           in size.
//
//    Count - the number of bytes to decrypt.
//
//    IV - only used for CBC type, it's an array containing the initial value
//         that was used to encrypt the data with.
//
// Returns - Nothing.
///////////////////////////////////////////////////////////////////////////////
void decrypt_aes(uint8_t *Data, uint16_t Count, uint8_t *IV = 0)
{
   union
   {
      uint8_t b[16];
      uint32_union_t u[4];
   } dData;
   uint8_t i,k;
   int8_t j;
   uint8_t Loops;
   uint16_t eCount = 0;
   uint16_t sCount = 0;
  #if AES_BLOCK_TYPE == AES_TYPE_CBC
   uint8_t sIV[16];
   uint8_t cIV[16];
  #endif
   
   Loops = Count / 16;
   
   if((Count % 16) != 0)
      Loops++;
   
   for(i=0;i<Loops;i++)
   {
      for(j=0;j<4;j++)
      {
         for(k=0;k<4;k++,eCount++)
            dData.u[j].b[k] = Data[eCount];
      }
      
     #if AES_BLOCK_TYPE == AES_TYPE_CBC
      if(i == 0)
      {
         for(j=0;j<16;j++)
            cIV[j] = IV[j];
      }
      else
      {
         for(j=0;j<16;j++)
            cIV[j] = sIV[j];
      }
      
      if(i < (Loops - 1))
      {
         for(j=0;j<4;j++)
         {
            for(k=0;k<4;k++)
               sIV[(j * 4) + k] = dData.u[j].b[k];
         }
      }
     #endif
      
      dData.u[0].dw ^= RoundKey[10][0];
      dData.u[1].dw ^= RoundKey[10][1];
      dData.u[2].dw ^= RoundKey[10][2];
      dData.u[3].dw ^= RoundKey[10][3];
      
      for(j=9;j>=0;j--)
      {
         //Inverse ShiftRows
         InverseShiftRows((uint32_union_t *)&dData, 1, 1);
         InverseShiftRows((uint32_union_t *)&dData, 2, 2);
         InverseShiftRows((uint32_union_t *)&dData, 3, 3);
         
         //Inverse SubBytes
         for(k=0;k<16;k++)
            dData.b[k] = InverseSBox[dData.b[k]];
         
         //RoundKey
         k = (uint8_t)j;  //made this change to work around a compiler bug in PCH compiler
         dData.u[0].dw ^= RoundKey[k][0];
         dData.u[1].dw ^= RoundKey[k][1];
         dData.u[2].dw ^= RoundKey[k][2];
         dData.u[3].dw ^= RoundKey[k][3];
         
         if(j > 0)
         {
            //Inverse MixColumns
            for(k=0;k<4;k++)
               InverseMixColumns((uint32_union_t *)&dData, k);
         }
      }
      
     #if AES_BLOCK_TYPE == AES_TYPE_CBC
      for(j=0;j<4;j++)
      {
         for(k=0;k<4;k++)
            dData.u[j].b[k] ^= cIV[(j*4) + k];
      }
     #endif
     
      for(j=0;j<16;j++,sCount++)
      {
         if(sCount < Count)
            Data[sCount] = dData.b[j];
      }
   }
}

/////////////////////////////// Helper Functions //////////////////////////////

#if AES_USE_GF28MULTIPLY_TABLES == FALSE
/* 
   MultiplyGF28() performs a GF(2^8) multiplication of 2 bytes.
*/
uint8_t MultiplyGF28(uint8_t a, uint8_t b)
{
   uint8_t i;
   uint8_t p;
   
   for(i=0,p=0;i<7;i++)
   {
      if((a == 0) || (b == 0))
         break;
      
      if(bit_test(b, 0))
         p ^= a;
      
      b >>= 1;
      
      if(shift_left(&a, 1, 0))
         a ^= 0x1B;
   }
   
   if((a != 0) && (b != 0))   //if b isn't 0 then bit 0 has to be a 1 at this point
      p ^= a;
   
   return(p);
}
#endif

/*
   ShiftRows() - used to do the shift row portion of the encryption.
*/
void ShiftRows(uint32_union_t *Data, uint8_t Row, uint8_t Bytes, int1 IsInverse=FALSE)
{
   uint32_union_t Temp;
   uint8_t bTemp;
   
   Temp.dw = make32(Data[0].b[Row], Data[1].b[Row], Data[2].b[Row], Data[3].b[Row]);
   
   switch(Bytes)
   {
      case 1: 
         if(IsInverse)
         {
            bTemp = Temp.b[0];
            Temp.b[0] = Temp.b[1];
            Temp.b[1] = Temp.b[2];
            Temp.b[2] = Temp.b[3];
            Temp.b[3] = bTemp;
         }
         else
         {
            bTemp = Temp.b[3];
            Temp.b[3] = Temp.b[2];
            Temp.b[2] = Temp.b[1];
            Temp.b[1] = Temp.b[0];
            Temp.b[0] = bTemp;
         }
         break;
      case 2:
         bTemp = Temp.b[3];
         Temp.b[3] = Temp.b[1];
         Temp.b[1] = bTemp;
         bTemp = Temp.b[2];
         Temp.b[2] = Temp.b[0];
         Temp.b[0] = bTemp;
         break;
      case 3:
         if(IsInverse)
         {
            bTemp = Temp.b[3];
            Temp.b[3] = Temp.b[2];
            Temp.b[2] = Temp.b[1];
            Temp.b[1] = Temp.b[0];
            Temp.b[0] = bTemp;
         }
         else
         {
            bTemp = Temp.b[3];
            Temp.b[3] = Temp.b[0];
            Temp.b[0] = Temp.b[1];
            Temp.b[1] = Temp.b[2];
            Temp.b[2] = bTemp;
         }
         break;
   }
   
   Data[0].b[Row] = Temp.b[3];
   Data[1].b[Row] = Temp.b[2];
   Data[2].b[Row] = Temp.b[1];
   Data[3].b[Row] = Temp.b[0];
}

/*
   InverseShiftRows() - used to do the inverse shift row portion of the decryption.
*/
void InverseShiftRows(uint32_union_t *Data, uint8_t Row, uint8_t Bytes)
{
   ShiftRows(Data, Row, Bytes, TRUE);
}

/*
   MixColumns() - used to do the mix column portion of the encryption.
*/
void MixColumns(uint32_union_t *Data, uint8_t Column)
{
   uint32_union_t Temp;
   
   Temp.dw = Data[Column].dw;

  #if AES_USE_GF28MULTIPLY_TABLES == TRUE
   Data[Column].b[0] = GF28Multiply2[Temp.b[0]] ^ GF28Multiply3[Temp.b[1]] ^ Temp.b[2] ^ Temp.b[3];
   Data[Column].b[1] = Temp.b[0] ^ GF28Multiply2[Temp.b[1]] ^ GF28Multiply3[Temp.b[2]] ^ Temp.b[3];
   Data[Column].b[2] = Temp.b[0] ^ Temp.b[1] ^ GF28Multiply2[Temp.b[2]] ^ GF28Multiply3[Temp.b[3]];
   Data[Column].b[3] = GF28Multiply3[Temp.b[0]] ^ Temp.b[1] ^ Temp.b[2] ^ GF28Multiply2[Temp.b[3]];
  #else
   Data[Column].b[0] = MultiplyGF28(2, Temp.b[0]) ^ MultiplyGF28(3, Temp.b[1]) ^ Temp.b[2] ^ Temp.b[3];
   Data[Column].b[1] = Temp.b[0] ^ MultiplyGF28(2, Temp.b[1]) ^ MultiplyGF28(3, Temp.b[2]) ^ Temp.b[3];
   Data[Column].b[2] = Temp.b[0] ^ Temp.b[1] ^ MultiplyGF28(2, Temp.b[2]) ^ MultiplyGF28(3, Temp.b[3]);
   Data[Column].b[3] = MultiplyGF28(3, Temp.b[0]) ^ Temp.b[1] ^ Temp.b[2] ^ MultiplyGF28(2, Temp.b[3]);
  #endif
}

/*
   InverseMixColumns() - used to do the inverse mix column portion of the decryption.
*/
void InverseMixColumns(uint32_union_t *Data, uint8_t Column)
{
   uint32_union_t Temp;
   
   Temp.dw = Data[Column].dw;

  #if AES_USE_GF28MULTIPLY_TABLES == TRUE
   Data[Column].b[0] = GF28Multiply14[Temp.b[0]] ^ GF28Multiply11[Temp.b[1]] ^ GF28Multiply13[Temp.b[2]] ^ GF28Multiply9[Temp.b[3]];
   Data[Column].b[1] = GF28Multiply9[Temp.b[0]] ^ GF28Multiply14[Temp.b[1]] ^ GF28Multiply11[Temp.b[2]] ^ GF28Multiply13[Temp.b[3]];
   Data[Column].b[2] = GF28Multiply13[Temp.b[0]] ^ GF28Multiply9[Temp.b[1]] ^ GF28Multiply14[Temp.b[2]] ^ GF28Multiply11[Temp.b[3]];
   Data[Column].b[3] = GF28Multiply11[Temp.b[0]] ^ GF28Multiply13[Temp.b[1]] ^ GF28Multiply9[Temp.b[2]] ^ GF28Multiply14[Temp.b[3]];
  #else
   Data[Column].b[0] = MultiplyGF28(14, Temp.b[0]) ^ MultiplyGF28(11, Temp.b[1]) ^ MultiplyGF28(13, Temp.b[2]) ^ MultiplyGF28(9, Temp.b[3]);
   Data[Column].b[1] = MultiplyGF28(9, Temp.b[0]) ^ MultiplyGF28(14, Temp.b[1]) ^ MultiplyGF28(11, Temp.b[2]) ^ MultiplyGF28(13, Temp.b[3]);
   Data[Column].b[2] = MultiplyGF28(13, Temp.b[0]) ^ MultiplyGF28(9, Temp.b[1]) ^ MultiplyGF28(14, Temp.b[2]) ^ MultiplyGF28(11, Temp.b[3]);
   Data[Column].b[3] = MultiplyGF28(11, Temp.b[0]) ^ MultiplyGF28(13, Temp.b[1]) ^ MultiplyGF28(9, Temp.b[2]) ^ MultiplyGF28(14, Temp.b[3]);
  #endif
}

#endif
